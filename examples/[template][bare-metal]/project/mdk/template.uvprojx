# Keil uVision project template.uvprojx, settings and files
target V2M-MPS2-CM4 (6210000::V6.21::.\ArmCompilerforEmbedded6.21)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IROM(0x00000000,0x400000) IRAM(0x20000000,0x400000) CPUTYPE("Cortex-M4") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps2
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
  group Source Files
    ../../: main.c app_cfg.h virtual_resource_demo.c virtual_resource_demo.h arm_2d_scene_meter.c MeterPanel.c arm_2d_scene_fitness.c arm_2d_scene_fitness.h
  group platform
    ../../../common/platform/: app_platform.c Board_GLCD.h platform.h
  group bsp_mps2
    ../../../common/platform/mps2/: GLCD_V2M-MPS2.c platform_mps2.c stdout_USART.c GLCD_Config.h
  group bsp_mps3
    ../../../common/platform/mps3/: GLCD_V2M-MPS3_AN540.c platform_mps3.c stdout_USART.c GLCD_Config.h
  group bsp_stm32f746g-discovery
    ../../../common/platform/stm32f746g-discovery/: GLCD_746G_Discovery.c platform_stm32f746g_discovery.c GLCD_Config.h
target FastModel (6190000::V6.19::ARMCLANG)
  device: CMSDK_CM4_FP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: as above
  output: template
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0,ITERATION_CNT=10
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler --diag_suppress=6314,6329
  group added to the first target's files
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target V2M-MPS2-CM33 (6210000::V6.21::.\ArmCompilerforEmbedded6.21)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;;..\..\..\common\platform\mps2
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\MPS2_CM33.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
  group added to the first target's files
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target V2M-MPS3-CM55 (6210000::V6.21::ARMCLANG)
  device: ARMCM55 ARM
  pack: ARM.CMSIS_DFP.0.0.0
  cpu: IRAM(0x30000000,0x00020000) IRAM2(0x20000000,0x00020000) IROM(0x10000000,0x00200000) IROM2(0x00000000,0x00200000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x0 size 0x200000
  memory RVCT9: RAM 0x30000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
  group added to the first target's files
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target V2M-MPS2-CM0+ (6210000::V6.21::.\ArmCompilerforEmbedded6.21)
  device: CMSDK_CM0plus ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
  group added to the first target's files
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target V2M-MPS2-CM7 (6210000::V6.21::.\ArmCompilerforEmbedded6.21)
  device: CMSDK_CM7_DP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.8.1
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: GLCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax -Wno-nonportable-include-path
  c include: as above
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\mps2.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
  group added to the first target's files
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target STM32F746G-Discovery (6210000::V6.21::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: __GLCD_CFG_SCEEN_WIDTH__=480,__GLCD_CFG_SCEEN_HEIGHT__=276,__DISP0_CFG_SCEEN_WIDTH__=480,__DISP0_CFG_SCEEN_HEIGHT__=272,__DISP0_CFG_PFB_BLOCK_WIDTH__=480,__DISP0_CFG_PFB_BLOCK_HEIGHT__=27
  c misc: -Wno-nonportable-include-path -Omax
  c include: ..\..\..\common\platform;..\..\..\common\platform\stm32f746g-discovery;..\..\
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746g.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
  group added to the first target's files
    ../../../../Acceleration/Arm/ACI/: arm_2d_rgb565_aci_lib.c arm_2d_rgb565_aci_lib.h arm_2d_user_aci.h
target AN547-Cortex-M55_r0 (6210000::V6.21::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.4.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0,__USE_AN547__
  c misc: -Wno-padded -mcpu=cortex-m55
  c include: ..\..\..\common\platform;..\..\;..\..\..\common\platform\mps3\v2m_mps3;..\..\..\common\platform\mps3;..\..\..\..\CDE
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
target STM32F746G-Discovery-AC5 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: as above
  output: template
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=2
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x3f800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\stm32f746g.sct
  link misc: --entry=Reset_Handler 
--diag_suppress=6314,6329
target V2M-MPS3-CM85 (6210000::V6.21::.\ArmCompilerforEmbedded6.21)
  device: ARMCM85 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x30000000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x10000000,0x00200000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ESEL ELITTLE
  output: template
  c flags: oTime=1 OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=2
  c define: LCD_MIRROR_X=1,GLCD_MIRROR_Y=0
  c misc: -Omax -Wno-invalid-utf8
  c include: as above
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: .\MPS3_CM55_DTCM.sct
  link misc: --entry=Reset_Handler
--diag_suppress=6314,6329,6848
software components: Acceleration:Arm-2D Extras:Controls 1.5.7, Acceleration:Arm-2D Extras:LCD ASCII Printf 2.1.1, Acceleration:Arm-2D Helper:Display Adapter 1.9.0, Acceleration:Arm-2D Helper:PFB 1.8.4, Acceleration:Arm-2D Helper:Scene 1.2.1, Acceleration:Arm-2D:Alpha-Blending 1.1.5, Acceleration:Arm-2D:Core 1.1.5, Acceleration:Arm-2D:Transform 1.1.6, CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, Device:Definition 2.0.0, Device:Native Driver:SysCounter 1.1.0, Device:Native Driver:SysTimer 1.1.0, Device:Native Driver:Timeout 1.0.0, Device:Startup 1.0.0, Device:Startup 1.1.0, Device:Startup 2.0.0, Device:Startup 2.1.0, Utilities:perf_counter:Core 2.2.5, Board Support:Drivers:SDRAM 1.1.1, Board Support:Common 2.0.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:USART 1.0.3, CMSIS Driver:USART 1.21.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:STM32Cube Framework:Classic 1.3.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:LTDC 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:SDRAM 1.3.0, Device:STM32Cube LL:Common 1.3.0, Device:STM32Cube LL:PWR 1.3.0, Device:STM32Cube LL:RCC 1.3.0, Device:STM32Cube LL:UTILS 1.3.0, Device:Startup 1.0.3, Device:Startup 1.1.0, Device:Startup 1.1.0, Device:Startup 1.1.0, Device:Startup 1.2.5
